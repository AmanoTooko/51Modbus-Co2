# Keil uVision project Co2.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: Co2 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c STARTUP.A51
  group Platform
    ./: IO.c IO.h Common.h uart.c uart.h
  group APP
    ./: modbus.c modbus.h
